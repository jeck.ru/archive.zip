# Autodesk Inventor assembly: Сборка
## iProperties
Created: 2009-12
Part Number: Сборка
Document SubType Name: Assembly
Designer: Jeck
Author: Jeck
